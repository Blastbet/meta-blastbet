SUMMARY = "Minimal Blast distribution image"

IMAGE_FEATURES += "splash"

LICENSE = "MIT"

inherit core-image
