KBRANCH_udoo-quad ?= "standard/base"

COMPATIBLE_MACHINE_udoo-quad = "udoo-quad"

SRCREV_machine_udoo-quad ?= "dbe692d91c8e55d1430f2c45fd578c8e4e71e482"

KMACHINE_udoo-quad ?= "${MACHINE}"
